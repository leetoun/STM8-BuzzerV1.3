# IAR project Backup of UART.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; library/inc; source
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LSM9DS1.hex
  ILINK.IlinkOutputFile: LSM9DS1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Library
    library/src/: stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_spi.c stm8s_uart2.c
  group Source
    source/: lsm9ds1_stm8s.c main.c stm8s_it.c uart2_module.c
